# Keil uVision project Senior Deisgn.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ATSAML21G18B Microchip
  pack: Microchip.SAML21_DFP.3.6.105
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30000000,0x2000) IROM(0x00000000,0x40000) IROM2(0x00400000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Senior Deisgn
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x400000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30000000 size 0x2000
  group Main Source Files
    ./: main.cpp system_setup.h system_setup.cpp bluetooth.cpp bluetooth.h SendingData.cpp SendingData.h gsm_usart.h gsm_usart.cpp
  group Drivers
    ./: SERCOM.h RTC.h RTC.cpp SERCOM.cpp DMA.cpp DMA.h
  group Smartmesh IP
    ./: API.cpp API.h
  group Ethereum
    ./: asm_arm.inc asm_arm_mult_square.inc asm_arm_mult_square_umaal.inc asm_avr.inc asm_avr_mult_square.inc byte_order.c byte_order.h Contract.c Contract.h curve-specific.inc mainRLP.c platform-specific.inc RLP.c RLP.h sha3.c sha3.h types.h uECC.c uECC.h uECC_vli.h ustd.h utils.c utils.h
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Coroutines 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Message Buffer 10.4.6, RTOS:Stream Buffer 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Device:Startup 3.6.0
